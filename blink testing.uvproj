# Keil uVision project blink testing.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: blink testing
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s blink testing.c
    C:/Keilv4/TM4C123Valvanoware/BoardSupportPackage_4C123/RTE/Device/TM4C123GH6PM/: system_TM4C123.c
    C:/Keilv4/EE319Kware/inc/: tm4c123gh6pm.h
